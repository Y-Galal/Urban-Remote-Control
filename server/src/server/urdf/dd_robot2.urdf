Commit message: edited readme and file names

File: server/src/server/urdf/dd_robot2.urdf (robot description, URDF)
Before this commit: robot dd_robot, 5 links, 4 joints
Links:
- link hokuyo_link: geometry collision box size=0.1 0.1 0.1; visual mesh filename=package://server/meshes/hokuyo.dae
